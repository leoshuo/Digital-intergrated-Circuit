* FILE: inv.sp

* SPICE netlist for "inv" generated by MMI_SUE5.6.29 on Wed Oct 18
*+ 18:14:36 CDT 2017.

.SUBCKT inv A Y
M_1 Y A gnd gnd n W='3*1u' L='0.6*1u'
M_2 Y A vdd vdd p W='6*1u' L='0.6*1u'
.ENDS	$ inv

.GLOBAL gnd vdd
