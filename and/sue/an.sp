* FILE: an.sp

* SPICE netlist for "an" generated by MMI_SUE5.6.37 on Fri Dec 07
*+ 10:39:39 CST 2018.

.SUBCKT an A B Z
M_1 net_1 A vdd vdd p W='6*1u' L='0.6*1u'
M_2 vdd B net_1 vdd p W='6*1u' L='0.6*1u'
M_3 net_1 A net_2 gnd n W='3*1u' L='0.6*1u'
M_4 net_2 B gnd gnd n W='3*1u' L='0.6*1u'
M_5 Z net_1 gnd gnd n W='3*1u' L='0.6*1u'
M_6 Z net_1 vdd vdd p W='6*1u' L='0.6*1u'
.ENDS	$ an

.GLOBAL gnd vdd
